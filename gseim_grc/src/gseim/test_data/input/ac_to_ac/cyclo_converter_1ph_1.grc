options:
  parameters:
    author: mbp
    category: '[GRC Hier Blocks]'
    comment: ''
    copyright: ''
    delta_show_grid: '0'
    description: ''
    drawing_scheme: name
    engine_output: GUI_window
    generate_options: circuit
    id: cyclo_converter_1ph_1
    mirror: none
    placement: (0,0)
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    run: 'True'
    sizing_mode: fixed
    title: cyclo_converter_1ph_1
    wiring_style: rectilinear
  states:
    coordinate: [33, 21]
    rotation: 0
    state: enabled
blocks:
- name: clock_thyr$0
  id: clock_thyr
  parameters:
    T: '0'
    alpha: '10'
    beta: '0'
    comment: ''
    drawing_scheme: symbol
    dt: dt
    flag_frequency: '1'
    flag_period: '0'
    flag_tw_degrees: '1'
    frequency: f1
    mirror: none
    name: none
    port_block_x: '6'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    tw: '0'
    tw_deg: tw_deg
    x_high: x_high
    x_low: '0'
  states:
    coordinate: [138, 153]
    rotation: 0
    state: true
- name: clock_thyr$1
  id: clock_thyr
  parameters:
    T: '0'
    alpha: '130'
    beta: '0'
    comment: ''
    drawing_scheme: symbol
    dt: dt
    flag_frequency: '1'
    flag_period: '0'
    flag_tw_degrees: '1'
    frequency: f1
    mirror: none
    name: none
    port_block_x: '6'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    tw: '0'
    tw_deg: tw_deg
    x_high: x_high
    x_low: '0'
  states:
    coordinate: [138, 177]
    rotation: 0
    state: true
- name: clock_thyr$2
  id: clock_thyr
  parameters:
    T: '0'
    alpha: '310'
    beta: '0'
    comment: ''
    drawing_scheme: symbol
    dt: dt
    flag_frequency: '1'
    flag_period: '0'
    flag_tw_degrees: '1'
    frequency: f1
    mirror: none
    name: none
    port_block_x: '6'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    tw: '0'
    tw_deg: tw_deg
    x_high: x_high
    x_low: '0'
  states:
    coordinate: [138, 246]
    rotation: 0
    state: true
- name: clock_thyr$3
  id: clock_thyr
  parameters:
    T: '0'
    alpha: '190'
    beta: '0'
    comment: ''
    drawing_scheme: symbol
    dt: dt
    flag_frequency: '1'
    flag_period: '0'
    flag_tw_degrees: '1'
    frequency: f1
    mirror: none
    name: none
    port_block_x: '6'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    tw: '0'
    tw_deg: tw_deg
    x_high: x_high
    x_low: '0'
  states:
    coordinate: [138, 222]
    rotation: 0
    state: true
- name: clock_thyr$4
  id: clock_thyr
  parameters:
    T: '0'
    alpha: '250'
    beta: '0'
    comment: ''
    drawing_scheme: symbol
    dt: dt
    flag_frequency: '1'
    flag_period: '0'
    flag_tw_degrees: '1'
    frequency: f1
    mirror: none
    name: none
    port_block_x: '6'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    tw: '0'
    tw_deg: tw_deg
    x_high: x_high
    x_low: '0'
  states:
    coordinate: [138, 339]
    rotation: 0
    state: true
- name: clock_thyr$5
  id: clock_thyr
  parameters:
    T: '0'
    alpha: '70'
    beta: '0'
    comment: ''
    drawing_scheme: symbol
    dt: dt
    flag_frequency: '1'
    flag_period: '0'
    flag_tw_degrees: '1'
    frequency: f1
    mirror: none
    name: none
    port_block_x: '6'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    tw: '0'
    tw_deg: tw_deg
    x_high: x_high
    x_low: '0'
  states:
    coordinate: [138, 294]
    rotation: 0
    state: true
- name: connector_e_3$0
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [504, 63]
    rotation: 180
    state: true
- name: connector_e_3$1
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [504, 399]
    rotation: 0
    state: true
- name: connector_e_3$2
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [423, 177]
    rotation: 90
    state: true
- name: connector_e_3$3
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [504, 285]
    rotation: 90
    state: true
- name: connector_e_3$4
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [570, 63]
    rotation: 180
    state: true
- name: connector_e_3$5
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [633, 399]
    rotation: 0
    state: true
- name: connector_e_3$6
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [633, 285]
    rotation: 270
    state: true
- name: connector_e_3$7
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [714, 177]
    rotation: 270
    state: true
- name: connector_e_3$8
  id: connector_e_3
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [633, 63]
    rotation: 180
    state: true
- name: connector_e_4$0
  id: connector_e_4
  parameters:
    comment: ''
    drawing_scheme: none
    mirror: none
    name: none
    port_block_x: '1'
    port_block_y: '1'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'no'
  states:
    coordinate: [570, 399]
    rotation: 0
    state: true
- name: dummy_sink$0
  id: dummy_sink
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g1
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [276, 168]
    rotation: 0
    state: true
- name: dummy_sink$1
  id: dummy_sink
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g2
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [276, 297]
    rotation: 0
    state: true
- name: dummy_sink$2
  id: dummy_sink
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g3
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [276, 342]
    rotation: 0
    state: true
- name: dummy_sink$4
  id: dummy_sink
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g4
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [276, 237]
    rotation: 0
    state: true
- name: dummy_source$0
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g1
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [372, 96]
    rotation: 0
    state: true
- name: dummy_source$1
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g2
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [372, 318]
    rotation: 0
    state: true
- name: dummy_source$2
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g2
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [453, 96]
    rotation: 0
    state: true
- name: dummy_source$3
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g1
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [453, 318]
    rotation: 0
    state: true
- name: dummy_source$4
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g4
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [666, 354]
    rotation: 180
    state: true
- name: dummy_source$5
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g3
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [666, 132]
    rotation: 180
    state: true
- name: dummy_source$6
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g4
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [747, 132]
    rotation: 180
    state: true
- name: dummy_source$7
  id: dummy_source
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    n: g3
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
  states:
    coordinate: [747, 354]
    rotation: 180
    state: true
- name: ground$0
  id: ground
  parameters:
    comment: ''
    drawing_scheme: symbol
    mirror: none
    name: none
    port_block_x: '4'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
  states:
    coordinate: [561, 405]
    rotation: 0
    state: true
- name: or_2$0
  id: or_2
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    name: none
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '0'
    port_sep_y: '4'
    rotate_strict: 'no'
    y_high: '1.0'
  states:
    coordinate: [210, 153]
    rotation: 0
    state: true
- name: or_2$1
  id: or_2
  parameters:
    comment: ''
    drawing_scheme: name
    mirror: none
    name: none
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '0'
    port_sep_y: '4'
    rotate_strict: 'no'
    y_high: '1.0'
  states:
    coordinate: [210, 222]
    rotation: 0
    state: true
- name: r$0
  id: r
  parameters:
    comment: ''
    drawing_scheme: symbol
    k_scale: '1.0'
    mirror: none
    name: none
    port_block_x: '10'
    port_block_y: '4'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r: '10'
    rotate_strict: 'yes'
  states:
    coordinate: [561, 204]
    rotation: 270
    state: true
- name: s_thyristor_1$0
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [402, 93]
    rotation: 180
    state: true
- name: s_thyristor_1$1
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [402, 315]
    rotation: 180
    state: true
- name: s_thyristor_1$2
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [483, 93]
    rotation: 180
    state: true
- name: s_thyristor_1$3
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [483, 315]
    rotation: 180
    state: true
- name: s_thyristor_1$4
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [612, 315]
    rotation: 0
    state: true
- name: s_thyristor_1$5
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [612, 93]
    rotation: 0
    state: true
- name: s_thyristor_1$6
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [693, 315]
    rotation: 0
    state: true
- name: s_thyristor_1$7
  id: s_thyristor_1
  parameters:
    cap: cap
    comment: ''
    drawing_scheme: symbol
    mirror: v
    name: none
    port_block_x: '8'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '6'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    r_off: r_off
    r_on: r_on
    rotate_strict: 'yes'
    v_on: v_on
    x_high: x_high
  states:
    coordinate: [693, 93]
    rotation: 0
    state: true
- name: show_parameter$0
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: r$0
    font_size: '9'
    mirror: none
    name: none
    parameter_name: r
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [582, 225]
    rotation: 0
    state: true
- name: show_parameter$1
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: clock_thyr$5
    font_size: '9'
    mirror: none
    name: none
    parameter_name: alpha
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [114, 297]
    rotation: 0
    state: true
- name: show_parameter$2
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: clock_thyr$4
    font_size: '9'
    mirror: none
    name: none
    parameter_name: alpha
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [108, 342]
    rotation: 0
    state: true
- name: show_parameter$3
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: clock_thyr$0
    font_size: '9'
    mirror: none
    name: none
    parameter_name: alpha
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [114, 156]
    rotation: 0
    state: true
- name: show_parameter$4
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: clock_thyr$1
    font_size: '9'
    mirror: none
    name: none
    parameter_name: alpha
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [108, 180]
    rotation: 0
    state: true
- name: show_parameter$5
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: clock_thyr$3
    font_size: '9'
    mirror: none
    name: none
    parameter_name: alpha
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [108, 225]
    rotation: 0
    state: true
- name: show_parameter$6
  id: show_parameter
  parameters:
    comment: ''
    drawing_scheme: text
    element_name: clock_thyr$2
    font_size: '9'
    mirror: none
    name: none
    parameter_name: alpha
    port_block_x: '4'
    port_block_y: '4'
    port_sep_x: '4'
    port_sep_y: '4'
    rotate_strict: 'no'
    show_name: do_not_show
  states:
    coordinate: [108, 249]
    rotation: 0
    state: true
- name: vsrc_ac$0
  id: vsrc_ac
  parameters:
    a: Vm
    comment: ''
    drawing_scheme: symbol
    f_hz: f0
    mirror: none
    name: none
    phi_deg: '0'
    port_block_x: '5'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    t0: '0'
    vdc: '0'
  states:
    coordinate: [342, 204]
    rotation: 0
    state: true
- name: vsrc_ac$1
  id: vsrc_ac
  parameters:
    a: Vm
    comment: ''
    drawing_scheme: symbol
    f_hz: f0
    mirror: none
    name: none
    phi_deg: '0'
    port_block_x: '5'
    port_block_y: '10'
    port_offset_b: '0'
    port_offset_l: '0'
    port_offset_r: '0'
    port_offset_t: '0'
    port_sep_x: '0'
    port_sep_y: '0'
    rotate_strict: 'yes'
    t0: '0'
    vdc: '0'
  states:
    coordinate: [777, 204]
    rotation: 0
    state: true
connections:
- [clock_thyr$0, '0', or_2$0, '0']
- [clock_thyr$1, '0', or_2$0, '1']
- [clock_thyr$2, '0', or_2$1, '1']
- [clock_thyr$3, '0', or_2$1, '0']
- [clock_thyr$4, '0', dummy_sink$2, '0']
- [clock_thyr$5, '0', dummy_sink$1, '0']
- [connector_e_3$0, el0, connector_e_3$4, er0]
- [connector_e_3$2, el0, s_thyristor_1$1, eb0]
- [connector_e_3$2, er0, s_thyristor_1$0, et0]
- [connector_e_3$3, el0, s_thyristor_1$3, eb0]
- [connector_e_3$3, et0, vsrc_ac$0, eb0]
- [connector_e_3$5, el0, connector_e_4$0, er0]
- [connector_e_3$5, er0, s_thyristor_1$6, eb0]
- [connector_e_3$5, et0, s_thyristor_1$4, eb0]
- [connector_e_3$6, el0, s_thyristor_1$5, eb0]
- [connector_e_3$6, er0, s_thyristor_1$4, et0]
- [connector_e_3$6, et0, vsrc_ac$1, eb0]
- [connector_e_3$7, el0, s_thyristor_1$7, eb0]
- [connector_e_3$7, er0, s_thyristor_1$6, et0]
- [connector_e_3$7, et0, vsrc_ac$1, et0]
- [connector_e_3$8, el0, s_thyristor_1$7, et0]
- [connector_e_3$8, er0, connector_e_3$4, el0]
- [connector_e_3$8, et0, s_thyristor_1$5, et0]
- [connector_e_4$0, el0, connector_e_3$1, er0]
- [dummy_source$0, '0', s_thyristor_1$0, '0']
- [dummy_source$1, '0', s_thyristor_1$1, '0']
- [dummy_source$2, '0', s_thyristor_1$2, '0']
- [dummy_source$3, '0', s_thyristor_1$3, '0']
- [dummy_source$4, '0', s_thyristor_1$4, '0']
- [dummy_source$5, '0', s_thyristor_1$5, '0']
- [dummy_source$6, '0', s_thyristor_1$7, '0']
- [dummy_source$7, '0', s_thyristor_1$6, '0']
- [ground$0, et0, connector_e_4$0, eb0]
- [or_2$0, '0', dummy_sink$0, '0']
- [or_2$1, '0', dummy_sink$4, '0']
- [r$0, el0, connector_e_3$4, et0]
- [r$0, er0, connector_e_4$0, et0]
- [s_thyristor_1$0, eb0, connector_e_3$0, er0]
- [s_thyristor_1$1, et0, connector_e_3$1, el0]
- [s_thyristor_1$2, eb0, connector_e_3$0, et0]
- [s_thyristor_1$2, et0, connector_e_3$3, er0]
- [s_thyristor_1$3, et0, connector_e_3$1, et0]
- [vsrc_ac$0, et0, connector_e_3$2, et0]
gparms:
  Vm: '325'
  cap: 10p
  dt: 1u
  f0: '50'
  f1: computed
  r_off: 10M
  r_on: 1m
  tw_deg: '2.5'
  v_on: '0'
  x_high: '1'
outvars:
  g1:
  - connection
  - - or_2$0
    - '0'
    - dummy_sink$0
    - '0'
  g2:
  - connection
  - - clock_thyr$5
    - '0'
    - dummy_sink$1
    - '0'
  g3:
  - connection
  - - clock_thyr$4
    - '0'
    - dummy_sink$2
    - '0'
  g4:
  - connection
  - - or_2$1
    - '0'
    - dummy_sink$4
    - '0'
  v_in:
  - outvar
  - - vsrc_ac$0
    - v
  v_out:
  - outvar
  - - r$0
    - v
solve_blocks:
- d_parms:
    algorithm_e: backward_euler
    algorithm_ex: backward_euler
    algorithm_x_startup: explicit
    algorithm_x_trns: RK4
    block_index: '0'
    bs23_fctr_max: '1.1'
    bs23_fctr_min: '0.8'
    bs23_tolr: '1.0e-8'
    delt_max_e: none
    delt_max_ex: none
    delt_max_x: none
    delt_min_e: none
    delt_min_ex: 1u
    delt_min_x: none
    e_nr_check_delx_all: 'no'
    e_nr_check_spice: 'yes'
    e_nr_dmp: 'no'
    e_nr_dmp0: 'no'
    e_nr_dmp_itermax: '50'
    e_nr_dmp_itermax0: '50'
    e_nr_dmp_k: '0.2'
    e_nr_dmp_k0: '0.2'
    e_nr_eps_delx_all: '1.0e-4'
    e_nr_itermax: '500'
    e_nr_itermax0: '500'
    e_nr_spice_abstol: '1.0e-6'
    e_nr_spice_reltol: '1.0e-3'
    e_nr_spice_vntol: '1.0e-4'
    e_nr_write_rhs2: 'no'
    ex_nr_check_delx_all: 'no'
    ex_nr_dmp: 'no'
    ex_nr_dmp0: 'no'
    ex_nr_dmp_itermax: '50'
    ex_nr_dmp_itermax0: '50'
    ex_nr_dmp_k: '0.2'
    ex_nr_dmp_k0: '0.2'
    ex_nr_eps_delx_all: '1.0e-4'
    ex_nr_itermax: '500'
    ex_nr_itermax0: '500'
    ex_nr_write_rhs2: 'no'
    factor_step_decrease: '0.6'
    factor_step_increase: '1.5'
    initial_sol: initialize
    initial_sol_file: none
    itmax_stepred: '20'
    itmax_trbdf2: '20'
    itmax_trns: '1000000'
    output_solution_file: none
    rkf45_fctr_max: '1.1'
    rkf45_fctr_min: '0.8'
    rkf45_tolr: '1.0e-8'
    solve_type: trns
    ssw_frequency: none
    ssw_ndiv: '200'
    ssw_nr_dmp: 'no'
    ssw_nr_dmp_itermax: '10'
    ssw_nr_dmp_k: '0.6'
    ssw_nr_eps_rhs: '1.0e-10'
    ssw_nr_itermax: '50'
    ssw_period: none
    ssw_period_mult: '2'
    t_end: 200m
    t_start: '0'
    t_startup: '0.0'
    trbdf2_tolr: '1.0e-5'
    tstep0_e: none
    tstep0_ex: 0.1m
    tstep0_x: none
    write_iter_n_e: '1000'
    write_iter_n_x: '1000'
    write_time_x: 'no'
    x_nr_check_delx_all: 'no'
    x_nr_dmp: 'no'
    x_nr_dmp0: 'no'
    x_nr_dmp_itermax: '50'
    x_nr_dmp_itermax0: '50'
    x_nr_dmp_k: '0.2'
    x_nr_dmp_k0: '0.2'
    x_nr_eps_delx_all: '1.0e-4'
    x_nr_itermax: '500'
    x_nr_itermax0: '500'
    x_nr_write_rhs2: 'no'
  index: '0'
  name: S1
  output_blocks:
  - out$0
  - out$1
output_blocks:
- d_parms:
    append: 'no'
    filename: out1.dat
    fixed_interval: none
    limit_lines: '1000000'
    t_end: none
    t_start: none
  index_slv: '0'
  name: out$0
  outvars:
  - v_out
  - v_in
- d_parms:
    append: 'no'
    filename: out2.dat
    fixed_interval: none
    limit_lines: '1000000'
    t_end: none
    t_start: none
  index_slv: '0'
  name: out$1
  outvars:
  - g1
  - g2
  - g3
  - g4
